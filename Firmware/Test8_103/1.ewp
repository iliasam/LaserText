# IAR project 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; HAVE_CONFIG_H
  ICCARM.CCIncludePath2: .\inc; ..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.hex
  ILINK.IlinkOutputFile: 1.out
  ILINK.IlinkIcfFile: D:\MYPROGS\STM32\Мелкие проекты\encoder_emulator\stm32f100_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group src
    src/: config.h laser_controlling.c lcd_worker.c main.c poly_mirror.c stm32f10x_it.c vertical_mirror.c
  group src/CMSIS
    src/CMSIS/: system_stm32f10x.c
  group src/inc
    src/inc/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
  group src/startup
    src/startup/: startup_stm32f10x_md_vl.s
  group src/StdPeriphLib
    src/StdPeriphLib/: stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
